FILESEXTRAPATHS_prepend := "${THISDIR}/busybox:"

SRC_URI += "file://install.cfg"


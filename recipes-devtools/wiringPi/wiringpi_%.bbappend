
COMPATIBLE_MACHINE_generic-armv7a = "${MACHINE}"


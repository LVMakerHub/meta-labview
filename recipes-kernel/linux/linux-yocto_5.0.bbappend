FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://usb-serial.cfg"


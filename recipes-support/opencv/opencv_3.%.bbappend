
ALLOW_EMPTY_${PN}-java = "1"

